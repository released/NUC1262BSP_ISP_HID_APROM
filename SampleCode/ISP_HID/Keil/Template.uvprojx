# Keil uVision project Template.uvprojx, settings and files
target Template (6120000::V6.12::.\ARMCLANG)
  device: NUC1262SE4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.18
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: ISP_HID +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\NUC1262\Include;..\..\..\Library\StdDriver\inc;..\..\Template
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4ff0
  memory RVCT10: RAM 0x20004ff0 size 0x10
  scatter file: .\hid_iap.sct
  link misc: --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC1262/Source/: system_NUC1262.c
    ../../../Library/Device/Nuvoton/NUC1262/Source/ARM/: startup_NUC1262.s
  group User
    ../: main.c
  group Library
    ../../../Library/StdDriver/src/: clk.c gpio.c timer.c uart.c fmc.c crc.c sys.c retarget.c
  group ISP
    ../: descriptors.c fmc_user.c hid_transfer.c isp_user.c targetdev.c usbd_user.c startup_NUC1262_user.s
